# Keil uVision project CLEANER_TEST.uvprojx, settings and files
target CLEANER_TEST (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: CLEANER_TEST
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --C99
  c include: ../Inc;   C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Inc;   C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;   C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/CMSIS/Include;   C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/CMSIS
    C:/Users/ZhouS/STM32Cube/Repository/STM32Cube_FW_F0_V1.5.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: spi.c stm32f0xx_it.c main.c tim.c gpio.c dma.c usart.c stm32f0xx_hal_msp.c Button.c CJSON.c Dust.c FPE.c Thread.c Tick.c SIM808.c md5.c
software components: CMSIS:CORE 4.1.0
